** sch_path: modules/loopgainprobe.sch
**.subckt loopgainprobe gnd A B
*.iopin gnd
*.iopin A
*.iopin B
Ii gnd x DC 0 AC 0
Vi x A DC 0 AC 0
Vnodebuffer B x 0
**.ends
.end
